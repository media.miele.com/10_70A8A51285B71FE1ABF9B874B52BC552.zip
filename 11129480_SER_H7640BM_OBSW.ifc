Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b5453a1a-446f-4076-b4ac-0ec6b0b87538, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T17:16:03+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11129480_SER_H7640BM_OBSW:22764026_SER_11129480_H7640BM_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm; Depth: 562 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 22764026_SER_11129480_H7640BM_OBSW; sets with these values: 2

# IfcDistributionPort, Port_354101_1
Description: Flow; FlowDirection: SOURCEANDSINK
